nmos: cs amp

.include C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\assets\45nm_CS.pm

.option TEMP=27C

V6 net2 0 dc 822.6m ac 1
Vdd net1 0 dc 1.2
R0 net1 out 500
mn0 out net2 0 0 NMOS W=5u L=45n

.control
set w_array = ( 620.0 620.0 620.0 620.0 620.0 620.0 620.0 620.0 620.0 620.0 620.0 631.0 631.0 631.0 631.0 631.0 631.0 631.0 631.0 631.0 631.0 631.0 642.0 642.0 642.0 642.0 642.0 642.0 642.0 642.0 642.0 642.0 642.0 653.0 653.0 653.0 653.0 653.0 653.0 653.0 653.0 653.0 653.0 653.0 664.0 664.0 664.0 664.0 664.0 664.0 664.0 664.0 664.0 664.0 664.0 675.0 675.0 675.0 675.0 675.0 675.0 675.0 675.0 675.0 675.0 675.0 686.0 686.0 686.0 686.0 686.0 686.0 686.0 686.0 686.0 686.0 686.0 697.0 697.0 697.0 697.0 697.0 697.0 697.0 697.0 697.0 697.0 697.0 708.0 708.0 708.0 708.0 708.0 708.0 708.0 708.0 708.0 708.0 708.0 719.0 719.0 719.0 719.0 719.0 719.0 719.0 719.0 719.0 719.0 719.0 730.0 730.0 730.0 730.0 730.0 730.0 730.0 730.0 730.0 730.0 730.0 741.0 741.0 741.0 741.0 741.0 741.0 741.0 741.0 741.0 741.0 741.0 752.0 752.0 752.0 752.0 752.0 752.0 752.0 752.0 752.0 752.0 752.0 763.0 763.0 763.0 763.0 763.0 763.0 763.0 763.0 763.0 763.0 763.0 774.0 774.0 774.0 774.0 774.0 774.0 774.0 774.0 774.0 774.0 774.0 785.0 785.0 785.0 785.0 785.0 785.0 785.0 785.0 785.0 785.0 785.0 796.0 796.0 796.0 796.0 796.0 796.0 796.0 796.0 796.0 796.0 796.0 807.0 807.0 807.0 807.0 807.0 807.0 807.0 807.0 807.0 807.0 807.0 818.0 818.0 818.0 818.0 818.0 818.0 818.0 818.0 818.0 818.0 818.0 829.0 829.0 829.0 829.0 829.0 829.0 829.0 829.0 829.0 829.0 829.0 840.0 840.0 840.0 840.0 840.0 840.0 840.0 840.0 840.0 840.0 840.0 851.0 851.0 851.0 851.0 851.0 851.0 851.0 851.0 851.0 851.0 851.0 862.0 862.0 862.0 862.0 862.0 862.0 862.0 862.0 862.0 862.0 862.0 873.0 873.0 873.0 873.0 873.0 873.0 873.0 873.0 873.0 873.0 873.0 884.0 884.0 884.0 884.0 884.0 884.0 884.0 884.0 884.0 884.0 884.0 895.0 895.0 895.0 895.0 895.0 895.0 895.0 895.0 895.0 895.0 895.0 906.0 906.0 906.0 906.0 906.0 906.0 906.0 906.0 906.0 906.0 906.0 917.0 917.0 917.0 917.0 917.0 917.0 917.0 917.0 917.0 917.0 917.0 928.0 928.0 928.0 928.0 928.0 928.0 928.0 928.0 928.0 928.0 928.0 939.0 939.0 939.0 939.0 939.0 939.0 939.0 939.0 939.0 939.0 939.0 950.0 950.0 950.0 950.0 950.0 950.0 950.0 950.0 950.0 950.0 950.0 961.0 961.0 961.0 961.0 961.0 961.0 961.0 961.0 961.0 961.0 961.0 972.0 972.0 972.0 972.0 972.0 972.0 972.0 972.0 972.0 972.0 972.0 983.0 983.0 983.0 983.0 983.0 983.0 983.0 983.0 983.0 983.0 983.0 994.0 994.0 994.0 994.0 994.0 994.0 994.0 994.0 994.0 994.0 994.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1005.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1016.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1027.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1038.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1049.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1060.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1071.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1082.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1093.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1104.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1115.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1126.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1137.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1148.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1159.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1170.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1181.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1192.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1203.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1214.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1225.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1236.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1247.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1258.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1269.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1280.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1291.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1302.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1313.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1324.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1335.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1346.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1357.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1368.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1379.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1390.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1401.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1412.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1423.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1434.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 1445.0 )
set r_array = ( 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 2.88e-06 3.255e-06 3.63e-06 4.005e-06 4.38e-06 4.755e-06 5.13e-06 5.505e-06 5.88e-06 6.255e-06 6.63e-06 )
set i = 836
let index = 1
repeat $i
    let r_test = $r_array[$&index]
    alter @mn0[w] = $w_array[$&index]
    alter R0 = r_test
    op
    let gm = @mn0[gm]
    let ro = 1/@mn0[gds]
    let a0 = gm*r_test
    let id = @mn0[id]
    let pw = id*1.2
    let cgd = @mn0[cgd]
    let cdb = abs(@mn0[cdb])
    let cp = (1+a0)*cgd+cdb
    let bw = 1/(2*pi*r_test*cp)
    wrdata C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\out\r-test.csv $r_array[$&index]
    wrdata C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\out\w-test.csv $w_array[$&index]
    wrdata C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\out\bw-test.csv bw
    wrdata C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\out\pw-test.csv pw
    wrdata C:\Users\tjtom\OneDrive\Desktop\File_Cabinet\Code\NgSpicePipeline\out\a0-test.csv a0
    set appendwrite
    let index = index + 1
end

.endc

.end
